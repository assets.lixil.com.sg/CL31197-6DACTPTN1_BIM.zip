Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2023-03-30T10:43:35
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.0.0.383 - Exporter 21.0.0.383 - Alternate UI 21.0.0.383
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Mar 30 10:43:35 2023 * Host: L0310_SARANYUK2 * Database: C:\Users\saranyuk\AppData\Local\Temp\59b96dd1-cee5-4443-ae7b-f284875e56ba\5ba9607e-30eb-4bb5-9461-aa1a4fc213a6\ifc * Database version: 5507 * Database creation date: Thu Mar 30 10:43:34 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Mar 30 10:43:34 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Mar 30 10:43:34 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 ft
Pset_ProductRequirements - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information

# IfcBuildingStorey: Level:1/4" Head, Level 1
LongName: Level 1; Elevation: 0 ft
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels

# IfcDistributionPort, Port_358014
Description: Flow; FlowDirection: SINK

# IfcFlowTerminal: CL31197-6DACTPTN1_REVIT:Acacia SupaSleek WH 3/4.5 Comp. Set WT, CL31197-6DACTPTN1_REVIT:Acacia SupaSleek WH 3/4.5 Comp. Set WT:358014
In: Level 1
Type - Classification: C1030200 Bath & Toilet Accessories (Uniformat); Material: Vitreous China, Plastic - White
Type - Pset_ManufacturerTypeInformation - Manufacturer: American Standard
Type - Pset_ProductRequirements - Category: Plumbing Fixtures
Type - Pset_QuantityTakeOff - Reference: Acacia SupaSleek WH 3/4.5 Comp. Set WT
Material: Plastic - White, Porcelain - White
Pset_DistributionFlowElementCommon - Reference: Acacia SupaSleek WH 3/4.5 Comp. Set WT; sets with these values: 2
